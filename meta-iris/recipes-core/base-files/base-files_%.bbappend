# dung issue/issue.net cua layer nay thay cho file cua meta-arago
FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

# chi doi ten distro trong recipe nay -> /etc/issue hien "Iris 2023.10"
DISTRO_NAME = "Iris"
